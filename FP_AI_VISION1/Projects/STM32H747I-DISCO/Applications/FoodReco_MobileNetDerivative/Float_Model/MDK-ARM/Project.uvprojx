# Keil uVision project Project.uvprojx, settings and files
target STM32H747I-DISCO_FoodReco_Float_Ext (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H747I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO, CORE_CM7, DATA_IN_ExtSDRAM, MEMORY_SCHEME=1, CAMERA_CAPTURE_RES=1, RESIZING_ALGO=1
  c include: ..\CM7\Inc;..\..\Extension\Drivers\BSP\STM32H747I-Discovery;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32H747I-Discovery;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\Fonts;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Middlewares\ST\STM32_AI\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_Image\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_Fs;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x91ffffff
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0xa00000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7xx_CM7_FLASH_Full_External.sct
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/ov9655/: ov9655.c
  group Drivers/BSP/STM32H747I_DISCO
    ../../../../../../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery.c stm32h747i_discovery_camera.c stm32h747i_discovery_lcd.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sdram.c stm32h747i_discovery_sd.c
    ../../Extension/Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery_camera_patch.c stm32h747i_discovery_lcd_patch.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Example/MDK-ARM
    ./: startup_stm32h747xx.s startup_cm4.s
  group Example/User/CM7
    ../CM7/Src/: ai_interface.c display.c fp_vision_app.c main.c network.c network_data.c onboard_validation.c sd_diskio.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Middlewares/STM32_AI
    ../../../../../../Middlewares/ST/STM32_AI/lib/: NetworkRuntime500_CM7_Keil.lib
  group Middlewares/STM32_Image
    ../../../../../../Middlewares/ST/STM32_Image/Src/: img_preprocess.c
  group Middlewares/STM32_Fs
    ../../../../../../Middlewares/ST/STM32_Fs/: stm32_fs.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
target STM32H747I-DISCO_FoodReco_Float_Split (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: as above
  output: STM32H747I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO, CORE_CM7, DATA_IN_ExtSDRAM, MEMORY_SCHEME=2, CAMERA_CAPTURE_RES=1, RESIZING_ALGO=1
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x91ffffff
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0xa00000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7xx_CM7_FLASH_Split.sct
target STM32H747I-DISCO_FoodReco_Float_Ext_Qspi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: as above
  output: STM32H747I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO, CORE_CM7, DATA_IN_ExtSDRAM, MEMORY_SCHEME=1, CAMERA_CAPTURE_RES=1, RESIZING_ALGO=1, WEIGHT_QSPI=1, WEIGHT_QSPI_PROGED=0, WEIGHT_EXEC_EXTRAM=0
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x91ffffff
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0xa00000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7xx_CM7_FLASH_Full_External_Qspi.sct
target STM32H747I-DISCO_FoodReco_Float_Split_Qspi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: as above
  output: STM32H747I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO, CORE_CM7, DATA_IN_ExtSDRAM, MEMORY_SCHEME=2, CAMERA_CAPTURE_RES=1, RESIZING_ALGO=1, WEIGHT_QSPI=1, WEIGHT_QSPI_PROGED=0, WEIGHT_EXEC_EXTRAM=0
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x91ffffff
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0xa00000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7xx_CM7_FLASH_Split_Qspi.sct
target STM32H747I-DISCO_FoodReco_Float_Ext_Sdram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: as above
  output: STM32H747I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO, CORE_CM7, DATA_IN_ExtSDRAM, MEMORY_SCHEME=1, CAMERA_CAPTURE_RES=1, RESIZING_ALGO=1, WEIGHT_QSPI=1, WEIGHT_QSPI_PROGED=0, WEIGHT_EXEC_EXTRAM=1
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x91ffffff
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0xa00000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7xx_CM7_FLASH_Full_External_Qspi.sct
target STM32H747I-DISCO_FoodReco_Float_Split_Sdram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: as above
  output: STM32H747I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO, CORE_CM7, DATA_IN_ExtSDRAM, MEMORY_SCHEME=2, CAMERA_CAPTURE_RES=1, RESIZING_ALGO=1, WEIGHT_QSPI=1, WEIGHT_QSPI_PROGED=0, WEIGHT_EXEC_EXTRAM=1
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x91ffffff
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0xa00000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7xx_CM7_FLASH_Split_Qspi.sct
