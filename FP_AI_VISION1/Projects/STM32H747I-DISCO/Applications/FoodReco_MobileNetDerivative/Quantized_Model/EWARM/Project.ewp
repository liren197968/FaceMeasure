# IAR project Project.ewp, settings and files
configuration STM32H747I-DISCO_FoodReco_Quantized_Split (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; DATA_IN_ExtSDRAM; MEMORY_SCHEME=2; CAMERA_CAPTURE_RES=1; RESIZING_ALGO=1
  ICCARM.CCIncludePath2: ..\CM7\Inc; ..\..\Extension\Drivers\BSP\STM32H747I-Discovery; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H747I-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Middlewares\ST\STM32_AI\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Image\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Fs; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Quantized_Model_Split_IntFlash_V1.1.0.bin
  ILINK.IlinkOutputFile: STM32H747I-DISCO_Quantized_Model_V1.1.0.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Split.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I-DISCO_FoodReco_Quantized_Int_Fps (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; DATA_IN_ExtSDRAM; MEMORY_SCHEME=3; CAMERA_CAPTURE_RES=2; RESIZING_ALGO=1
  OBJCOPY.OOCOutputFile: Quantized_Model_IntFps_IntFlash_V1.1.0.bin
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Full_Internal_Fps.icf
configuration STM32H747I-DISCO_FoodReco_Quantized_Ext (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; DATA_IN_ExtSDRAM; MEMORY_SCHEME=1; CAMERA_CAPTURE_RES=1; RESIZING_ALGO=1
  OBJCOPY.OOCOutputFile: Quantized_Model_Ext_IntFlash_V1.1.0.bin
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Full_External.icf
configuration STM32H747I-DISCO_FoodReco_Quantized_Int_Mem (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; DATA_IN_ExtSDRAM; MEMORY_SCHEME=4; CAMERA_CAPTURE_RES=2; RESIZING_ALGO=1
  OBJCOPY.OOCOutputFile: Quantized_Model_IntMem_IntFlash_V1.1.0.bin
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_Full_Internal_Mem.icf
  group Application/CM7
    ../CM7/Src/: ai_interface.c display.c fp_vision_app.c main.c network.c network_data.c onboard_validation.c sd_diskio.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/Common
    ../Common/Src/: system_stm32h7xx.c
  group Application/EWARM
    ./: startup_cm4.s startup_stm32h747xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/ov9655/: ov9655.c
  group Drivers/BSP/STM32H747I_Discovery
    ../../../../../../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery.c stm32h747i_discovery_camera.c stm32h747i_discovery_lcd.c stm32h747i_discovery_sd.c stm32h747i_discovery_sdram.c
    ../../Extension/Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery_camera_patch.c stm32h747i_discovery_lcd_patch.c
  group Drivers/STM32H7xx_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/STM32_AI
    ../../../../../../Middlewares/ST/STM32_AI/lib/: NetworkRuntime500_CM7_IAR.a
  group Middlewares/STM32_Fs
    ../../../../../../Middlewares/ST/STM32_Fs/: stm32_fs.c
  group Middlewares/STM32_Image
    ../../../../../../Middlewares/ST/STM32_Image/Src/: img_preprocess.c
